require linux-vuplus-3.1.1.inc

PR = "r4"

SRC_URI += "\
	"

