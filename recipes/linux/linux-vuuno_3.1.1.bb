require linux-vuplus-3.1.1.inc

PR = "r5"

SRC_URI += "\
        file://linux_3.1.1_vuuno.patch;patch=1;pnum=1 \
	"

