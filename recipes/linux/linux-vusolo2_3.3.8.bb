require linux-vuplus-3.3.8.inc

PR = "r1"
