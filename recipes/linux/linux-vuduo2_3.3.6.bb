require linux-vuplus-3.3.6.inc

PR = "r1"
