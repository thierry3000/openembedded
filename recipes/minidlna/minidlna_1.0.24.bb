require minidlna_1.0.inc

PR = "${INC_PR}.2"

